RDEPENDS_${PN} += "\
    iotivity-node \
    nodejs \
"
